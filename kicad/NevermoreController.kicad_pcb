# Repository raymondh2/NevermoreMaxController

## KiCad design kicad/NevermoreController.kicad_pcb

Parts:
C1, C2: 4.7u; C_0805_2012Metric
C3, C4, C5, C10, C11: 100n; C_0805_2012Metric
C6, C7: 7p; C_0805_2012Metric
C8: 4u7; C_0805_2012Metric; MPN C3225X7R1H106M250AC
C9: 10u; C_0805_2012Metric
D1: VIN; LED_0805_2012Metric
D2: 3v3; LED_0805_2012Metric
D3: STATUS; LED_0805_2012Metric
D4, D5: BAT54S; SOT-23; MPN ‎BAT54S-E3-18‎
D8: D_Schottky; D_SOD-323_HandSoldering; MPN 1PS76SB10,115; Digi-Key_PN 1727-3561-1-ND
D11: 5v; LED_0805_2012Metric
D12: PMEG4020ER,115; D_SOD-123; MPN 1PS76SB10,115; Digi-Key_PN 1727-3561-1-ND
F1: 3.5A; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MPN MFU0805FF03500P100
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02; Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal; MPN 105313xx02
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001; MPN 1050170001
J3: I2C2; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal; MPN S4B-PH-SM4-TB(LF)(SN)
J4: Debug; PinHeader_1x05_P2.54mm_Vertical
J5: FAN1; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal; MPN S4B-PH-SM4-TB(LF)(SN)
J6: I2C1; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal; MPN S4B-PH-SM4-TB(LF)(SN)
J7: I2C3; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal; MPN S4B-PH-SM4-TB(LF)(SN)
J8: I2C0; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal; MPN S4B-PH-SM4-TB(LF)(SN)
J10: Neo; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal; MPN S3B-PH-SM4-TB(LF)(SN)
L1: 22uH 2A; L_Bourns-SRN4018
R1: 4k7; R_0805_2012Metric
R2: 1k; R_0805_2012Metric
R3, R15, R16: 1K; R_0805_2012Metric
R4, R11, R12, R17: 10K; R_0805_2012Metric
R18: 9k53; R_0805_2012Metric
R19: 49K9; R_0805_2012Metric
SW1: RESET; Panasonic_EVQPUL_EVQPUC
U1: AP2127K-3.3; SOT-23-5
U2: ATSAMD21E18A-AUT; TQFP-32_7x7mm_P0.8mm
U3: AOZ1282CI; SOT-23-6
U4: 74LVC1G17; SOT-753
Y1: 32.768kHz; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering

Connections:
+3.3VA: C2.1, C3.1, C4.1, C5.1, D4.2, D5.2, J3.1, J4.2, J6.1, J7.1, J8.1, R2.2, R3.2, R4.1, R11.2, U1.5 (VOUT), U2.9 (VDDANA), U2.29 (VDDCORE), U2.30 (VDDIN)
+5V: C9.1, C11.1, J10.2, L1.2, R15.2, R19.1, U4.5 (VCC)
+12V: C8.1, F1.1, J5.2, R1.2, R17.2, U3.5 (VIN)
/I2C0_SCL: J8.3, U2.6 (PA05)
/I2C0_SDA: J8.2, U2.5 (PA04)
/I2C1_SCL: J6.3, U2.18 (PA17)
/I2C1_SDA: J6.2, U2.17 (PA16)
/I2C2_SCL: J3.3, U2.12 (PA09)
/I2C2_SDA: J3.2, U2.11 (PA08)
/I2C3_SCL: J7.3, U2.22 (PA23)
/I2C3_SDA: J7.2, U2.21 (PA22)
/Neopixel: U4.2
/PWM1: D5.3, R12.2, R16.1
/STATUS: D3.1 (K)
/SWCLK: J4.4, U2.31 (PA30)
/SWDIO: J4.5, U2.32 (PA31)
/TACH1: D4.3, D8.2 (A), R11.1
/USB_D+: J2.3 (D+), U2.24 (PA25)
/USB_D-: J2.2 (D-), U2.23 (PA24)
/neo: J10.3, U4.4
/~RESET: J4.3, R4.2, SW1.2, U2.26 (~RESET)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, D1.1 (K), D2.1 (K), D4.1, D5.1, D11.1 (K), D12.2 (A), J1.1, J2.4 (ID), J2.5 (GND), J2.6 (Shield), J3.4, J4.1, J5.1, J6.4, J7.4, J8.4, J10.1, R12.1, R18.2, SW1.1, U1.2 (GND), U2.10 (GND), U2.28 (GND), U3.2 (GND), U4.3 (GND)
unnamed: C6.1, U2.1 (PA00), Y1.1
unnamed: C7.1, U2.2 (PA01), Y1.2
unnamed: C10.1, U3.1 (BST)
unnamed: C10.2, D12.1 (K), L1.1, U3.6 (LX)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D8.1 (K), J5.3
unnamed: D11.2 (A), R15.1
unnamed: F1.2, J1.2
unnamed: J5.4, R16.2
unnamed: R17.1, U3.4 (EN)
unnamed: R18.1, R19.2, U3.3 (FB)
VBUS: C1.1, J2.1 (VBUS), U1.1 (VIN), U1.3 (EN)

Notes on the sheet:
SERCOM-ALT SERCOM0 PA04/05 SERCOM2 PA08/09 SERCOM3 PA16/17 SERCOM5 PA22/23
SERCOM SERCOM0 PA08/09 SERCOM1 PA16/17 SERCOM3 PA22/23

Board: 2 copper layers, 58.0 x 56.5 mm, 50 parts (0 on the bottom side), 34 nets.

## KiCad design kicad/noname.kicad_pcb

Board: 2 copper layers, 100.0 x 24.0 mm, 45 parts (0 on the bottom side), 31 nets.

Parts:
C1, C2, C6: 4.7u; C_0603_1608Metric
C3, C4, C5, C7: 100n; C_0402_1005Metric
D1, D2, D3, D4, D5: BAT54SW; SOT-323_SC-70
F1: 3.5A; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04; JST_PH_S4B-PH-SM4-TB_1x04-1MP_P2.00mm_Horizontal
J2, J3, J4: Conn_01x03; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal
J5: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J6: Conn_01x02; Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal
J7, J8: Conn_01x0; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3: IRLML6344TRPBF; SOT-23-3
R1, R4, R6, R8, R11, R13, R15, R16: 10K; R_0402_1005Metric
R2, R3, R5, R7, R9: 1K; R_0402_1005Metric
R10, R12, R14: 100R; R_0402_1005Metric
U1: STM32F042F6P6; TSSOP-20_4.4x6.5mm_P0.65mm
U2: AP2127K-3.3; SOT-23-5
U3: ZMOD4410

Connections:
+3.3VA: C2.1, C3.1, C4.1, C5.1, C6.2, C7.1, D1.2, D2.2, D3.2, D4.2, D5.2, J7.1, R1.2, R4.2, R6.2, R8.2, U1.5, U1.16, U2.5, U3.5, U3.10, U3.12
+12V: F1.1, J1.2, J2.2, J3.2, J4.2
/BOOT0: J7.2, R16.2, U1.1
/FAN2_O: J2.1, Q1.3
/FAN3_O: J3.1, Q2.3
/FAN4_O: J4.1, Q3.3
/I2C_SCL: U1.3, U3.1
/I2C_SDA: U1.2, U3.2
/PWM1: D1.3, R3.1, U1.7
/PWM2: R10.2, R11.1, U1.10
/PWM3: R12.2, R13.1, U1.13
/PWM4: R14.2, R15.1, U1.11
/SWCLK: J8.2, U1.20
/SWDIO: J8.1, U1.19
/TACH1: D2.3, R1.1, R2.1, U1.8
/TACH2: D3.3, R4.1, R5.1, U1.9
/TACH3: D4.3, R6.1, R7.1, U1.14
/TACH4: D5.3, R8.1, R9.1, U1.12
/USB_D+: J5.3, U1.18
/USB_D-: J5.2, U1.17
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, D1.1, D2.1, D3.1, D4.1, D5.1, J1.1, J5.4, J5.5, J5.6, J6.1, Q1.2, Q2.2, Q3.2, R11.2, R13.2, R15.2, R16.1, U1.15, U2.2, U3.6, U3.7, U3.9
unnamed: F1.2, J6.2
unnamed: J1.3, R2.2
unnamed: J1.4, R3.2
unnamed: J2.3, R5.2
unnamed: J3.3, R7.2
unnamed: J4.3, R9.2
unnamed: Q1.1, R10.1
unnamed: Q2.1, R12.1
unnamed: Q3.1, R14.1
VBUS: C1.1, J5.1, U2.1, U2.3

## Commit log

2021-06-24 Initial
2021-06-24 Move libs
2021-06-26 Fix USB pinout
2021-06-26 Remove blind vias
2021-06-26 Add crystal and move i2c bus
2021-06-27 Adding Fan and Servo
2023-03-07 in progress
